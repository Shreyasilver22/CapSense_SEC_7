v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {icm_frame_sample - SCL transistor implementation} 0 -100 0 0 .5 .5 {}
T {Node labels connect equal names. Open child symbols to inspect their transistors.} 0 -60 0 0 .25 .25 {}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 0 0 0 {name=P0 lab=clk}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 60 0 0 {name=P1 lab=sample_valid}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 120 0 0 {name=P2 lab=rst_n}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 180 0 0 {name=P3 lab=sample_en}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 240 0 0 {name=P4 lab=vdd}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 300 0 0 {name=P5 lab=vss}
C {./icm_dfcl11.sym} 160 180 0 0 {name=XFF1}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 60 0 0 {name=L1 lab=clk}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 100 0 0 {name=L2 lab=sample_valid}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 140 0 0 {name=L3 lab=rst_n}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 180 0 0 {name=L4 lab=unused_qb1}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 220 0 0 {name=L5 lab=delay1}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 260 0 0 {name=L6 lab=vss}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 300 0 0 {name=L7 lab=vdd}
C {./icm_dfcl11.sym} 530 180 0 0 {name=XFF2}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 60 0 0 {name=L8 lab=clk}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 100 0 0 {name=L9 lab=delay1}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 140 0 0 {name=L10 lab=rst_n}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 180 0 0 {name=L11 lab=unused_qb2}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 220 0 0 {name=L12 lab=delay2}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 260 0 0 {name=L13 lab=vss}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 300 0 0 {name=L14 lab=vdd}
C {./icm_nor.sym} 900 180 0 0 {name=XN}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 750 100 0 0 {name=L15 lab=delay1}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 750 140 0 0 {name=L16 lab=delay2}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 750 180 0 0 {name=L17 lab=en_b}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 750 220 0 0 {name=L18 lab=vdd}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 750 260 0 0 {name=L19 lab=vss}
C {./icm_inv.sym} 1270 180 0 0 {name=XI}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 1120 120 0 0 {name=L20 lab=en_b}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 1120 160 0 0 {name=L21 lab=sample_en}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 1120 200 0 0 {name=L22 lab=vdd}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 1120 240 0 0 {name=L23 lab=vss}
