v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {icm_switch - SCL transistor implementation} 0 -100 0 0 .5 .5 {}
T {Node labels connect equal names. Open child symbols to inspect their transistors.} 0 -60 0 0 .25 .25 {}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 0 0 0 {name=P0 lab=a}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 60 0 0 {name=P1 lab=b}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 120 0 0 {name=P2 lab=en}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 180 0 0 {name=P3 lab=vdd}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 240 0 0 {name=P4 lab=vss}
C {./icm_inv.sym} 160 180 0 0 {name=XI}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 120 0 0 {name=L1 lab=en}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 160 0 0 {name=L2 lab=eb}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 200 0 0 {name=L3 lab=vdd}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 240 0 0 {name=L4 lab=vss}
C {./Transmission_v1_26.sym} 530 180 0 0 {name=XT}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 510 140 0 0 {name=L5 lab=en}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 510 220 0 0 {name=L6 lab=vss}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 490 180 0 0 {name=L7 lab=a}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 570 180 0 0 {name=L8 lab=b}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 550 220 0 0 {name=L9 lab=vdd}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 550 140 0 0 {name=L10 lab=eb}
