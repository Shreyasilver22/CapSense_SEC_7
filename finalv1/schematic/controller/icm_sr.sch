v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {icm_sr - SCL transistor implementation} 0 -100 0 0 .5 .5 {}
T {Node labels connect equal names. Open child symbols to inspect their transistors.} 0 -60 0 0 .25 .25 {}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 0 0 0 {name=P0 lab=set}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 60 0 0 {name=P1 lab=reset}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 120 0 0 {name=P2 lab=q}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 180 0 0 {name=P3 lab=qb}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 240 0 0 {name=P4 lab=vdd}
C {/usr/share/xschem/xschem_library/devices/iopin.sym} -250 300 0 0 {name=P5 lab=vss}
C {./icm_nor.sym} 160 180 0 0 {name=XQ}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 100 0 0 {name=L1 lab=reset}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 140 0 0 {name=L2 lab=qb}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 180 0 0 {name=L3 lab=q}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 220 0 0 {name=L4 lab=vdd}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 10 260 0 0 {name=L5 lab=vss}
C {./icm_nor.sym} 530 180 0 0 {name=XQB}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 100 0 0 {name=L6 lab=set}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 140 0 0 {name=L7 lab=q}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 180 0 0 {name=L8 lab=qb}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 220 0 0 {name=L9 lab=vdd}
C {/usr/share/xschem/xschem_library/devices/lab_pin.sym} 380 260 0 0 {name=L10 lab=vss}
